# Keil uVision project mqttstc.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: mqttstc +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./include/: delay.c esp.c GPIO.c myKey.c OLED.c uart.c
